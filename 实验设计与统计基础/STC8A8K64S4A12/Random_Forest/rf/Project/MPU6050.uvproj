# Keil uVision project MPU6050.uvproj, settings and files
target MPU6050 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: MPU6050 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Lib;..\inc;..\Project
  group USER
    ./: main.c ReadMe.txt
  group Lib
    ../Lib/: delay.c uart.c MPU6050.C
